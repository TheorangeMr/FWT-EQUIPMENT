# Keil uVision project FTW_BAJA_Text.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FTW_BAJA_Text +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\BSP\ADC;..\Library\STM32F10x_StdPeriph_Driver\inc;..\FreeRtos\include;..\FreeRtos\portable\ARM_CM3;..\User;..\BSP\USART;..\Library\CMSIS;..\BSP\PCM300D;..\BSP\SMBus;..\BSP\LED;..\BSP\KEY;..\BSP\Suspension displacement;..\BSP\mpu6050;..\BSP\delay-FreeRTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Library/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Library/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWILB
    ../Library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group BSP
    ../BSP/USART/: bsp_usart.c
    ../BSP/PCM300D/: bsp_pcm300d.c
    ../BSP/LED/: bsp_led.c
    ../BSP/KEY/: bsp_key.c
    ../BSP/mpu6050/: mpu6050.c bsp_i2c_mpu6050.c
    ../BSP/Suspension displacement/: bsp_xjwy.c
    ../BSP/ADC/: bsp_adc.c
    ../BSP/SMBus/: bsp_SMBus_temperature.c
  group USER
    ../User/: main.c FreeRTOSConfig.h stm32f10x_it.c
    ../BSP/delay-FreeRTOS/: bsp_delay.c
  group DOC
    ../Doc/: readme.txt
  group FreeRTOS/port
    ../FreeRtos/portable/ARM_CM3/: port.c
    ../FreeRtos/portable/MemMang/: heap_4.c
  group FreeRTOS/source
    ../FreeRtos/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
